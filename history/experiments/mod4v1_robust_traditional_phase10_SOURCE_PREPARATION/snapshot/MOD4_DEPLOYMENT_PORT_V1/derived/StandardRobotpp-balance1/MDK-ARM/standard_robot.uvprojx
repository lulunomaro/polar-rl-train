# Keil uVision project standard_robot.uvprojx, settings and files
target standard_robot_MOD4_PORT_STAGE1_UNBOUND (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: mod4_port_stage1_UNBOUND +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --diag_error=warning
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../application;../bsp/boards;../components/devices;../components/algorithm;../components/algorithm/Include;../components/support;../application/protocol;../components/controller;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../application/assist;../application/chassis;../application/gimbal;../application/other;../application/referee;../application/remote_control;../application/robot_cmd;../application/shoot;../application/IMU;../application/mechanical_arm;../application/music;../application/custom_controller;../application/communication;../application/calibrate;../application/typedef;../application/mod4_port
  asm include: ..\\Inc;../Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c can.c crc.c dma.c i2c.c rng.c rtc.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group boards
    ../bsp/boards/: bsp_adc.c bsp_buzzer.c bsp_can.c bsp_crc32.c bsp_delay.c bsp_flash.c bsp_fric.c bsp_imu_pwm.c bsp_i2c.c bsp_laser.c bsp_led.c bsp_rc.c bsp_rng.c bsp_spi.c bsp_usart.c bsp_uart.c bsp_pwm.c
  group devices
    ../components/devices/: OLED.c BMI088driver.c BMI088Middleware.c ist8310driver.c ist8310driver_middleware.c
  group algorithm
    ../components/algorithm/: AHRS.lib AHRS_middleware.c arm_cortexM4lf_math.lib user_lib.c
  group support
    ../components/support/: CRC8_CRC16.c fifo.c mem_mang4.c kalman_filter.c signal_generator.c clist.c
  group controller
    ../components/controller/: pid.c
  group assist
    ../application/assist/: detect_task.c develop_task.c data_exchange.c
  group calibrate
    ../application/calibrate/: calibrate.h calibrate_task.c calibrate_task.h
  group chassis
    ../application/chassis/: chassis.c chassis_power_control.c chassis_task.c chassis_balance.c chassis_balance_extras.c chassis_mecanum.c chassis_omni.c chassis_steering.c
  group communication
    ../application/communication/: communication_task.c communication.c usb_task.c
  group custom_controller
    ../application/custom_controller/: custom_controller.c custom_controller_task.c custom_controller_penguin_mini.c custom_controller_engineer.c custom_controller_connect.c
  group gimbal
    ../application/gimbal/: gimbal.c gimbal_task.c gimbal_yaw_pitch_direct.c gimbal_virtual.c
  group IMU
    ../application/IMU/: IMU_task.c IMU_solve.c
  group mechanical_arm
    ../application/mechanical_arm/: mechanical_arm.c mechanical_arm_task.c mechanical_arm_penguin_mini.c mechanical_arm_engineer.c
  group music
    ../application/music/: music_task.c music.c music_you.c music_unity.c music_canon.c music_castle_in_the_sky.c music_start.c music_referee.c music_error.c music_see_you_again.c music_hao_yun_lai.c music_meow.c music_gong_xi_fa_cai.c music_deja_vu.c
  group other
    ../application/other/: led_flow_task.c oled_task.c remote_control.c test_task.c voltage_task.c
  group referee
    ../application/referee/: referee.c referee_usart_task.c
  group remote_control
    ../application/remote_control/: ps2_task.c
  group robot_cmd
    ../application/robot_cmd/: CAN_receive.c CAN_cmd_dji.c CAN_cmd_cybergear.c motor.c CAN_cmd_damiao.c CAN_cmd_lingkong.c CAN_communication.c SupCap.c CAN_cmd_SupCap.c PWM_cmd_pump.c PWM_cmd_servo.c
  group shoot
    ../application/shoot/: shoot.c shoot_task.c shoot_fric_trigger.c
  group mod4_port_stage1_unbound
    ../application/mod4_port/: mod4_port_gate.c mod4_port_bridge.c mod4_port_gate.h mod4_port_bridge.h
software components: CMSIS:CORE 5.5.0
